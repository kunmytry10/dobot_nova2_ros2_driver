Commit message: Split hand-eye tools into optional package

File: src/dobot_description/urdf/nova2_robot.urdf (robot description, URDF)
Before this commit: robot nova2_robot, 8 links, 7 joints
Links:
- removed link dummy_link
- added link map
Joints:
- joint dummy_joint: parent dummy_link -> map
